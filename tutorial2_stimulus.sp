vDD vdd! 0 dc 1.8
vSS vss! gnd dc 0
vGND gnd 0 dc 0

vIN IN 0 pwl 10n 0 10.03n 0.07 10.1n 0.711 10.23n 1.5 10.28n 1.68 10.3n 1.72 10.31n 1.7 10.43n 1.8
